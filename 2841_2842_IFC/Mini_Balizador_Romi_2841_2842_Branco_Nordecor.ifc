Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-12-11T14:04:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Dec 11 14:04:13 2024 * Host: MichellyManno * Database: C:\Users\MICHEL~1\AppData\Local\Temp\9635c14e-5276-4bae-a55d-6b32f6dd305c\1e0920af-9094-46a2-acb0-598aec530907\ifc * Database version: 5507 * Database creation date: Wed Dec 11 14:04:12 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Dec 11 14:04:12 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Dec 11 14:04:12 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcDistributionPort, Port_328235
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: 2841 - Branco, Mini_Balizador_Romi_2841_2842_Nordecor_IFC:2841 - Branco:328235
In: Nível 1
Type - Classification: D5020200 Lighting Equipment (Uniformat); Material: Plástico - Acrílico - Transparente, Metal - Alumínio - Branco, Metal - Alumínio - Preto
Type - Dados - Data da atualização: 11/12/2024; Versão: 1
Type - Dados de identidade - Código de montagem: D5020200; Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Mini balizador de embutir, acabamento branco, LED 1W, 3000K 25lm; Descrição de montagem: Lighting Equipment; Desenvolvedor: Chek BIM; Fabricante: Nordecor; Fixação: Molas; Garantia: 2 anos; Grau de proteção: IP20; Localização: Camboriú/SC - Brasil; Modelo: 2841; Nome do tipo: 2841 - Branco; Número OmniClass: 23.80.70.11.14; Tipo de imagem: Imagem raster: 2841.png; Título OmniClass: General Luminaries, Directional; URL: https://nordecor.com.br; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/mini-balizador-led-embutir-quad-romi-1w-3-000k/
Type - Elétrico - Comentários de voltagem: 100-240V; Fator de potência - Luminária: 0.5; Lâmpada: LED
Type - Elétrico - Cargas - Carga aparente - Luminária: 0 W
Type - Engenharia elétrica - Voltagem - Luminária: 0 V
Type - Estrutural - Peso: 0.056
Type - Fotométricos - Fluxo luminoso: 25 lm; Grau de abertura: 0 deg; IRC: 90; Potência: 1 W; Temperatura de cor: 3000 K
Type - Gráficos - Simbologia: Imagem raster: 2841 2D.png
Type - Materiais e acabamentos - Difusor: Plástico - Acrílico - Transparente; Dissipador: Metal - Alumínio - Preto; Luminária: Metal - Alumínio - Branco
Type - Outros - Categoria: Luminárias; Branco: yes; Nome da família: Mini_Balizador_Romi_2841_2842_Nordecor_IFC; Preto: no
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes; Fonte luminosa: yes
Cotas - Área: 0.00327606 m2; Volume: 0.0000136735 m3
Dados de identidade - Marca: 1
Elétrico - Circuitos - Dados elétricos: 0 V/1-0 VA
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Mini_Balizador_Romi_2841_2842_Nordecor_IFC: 2841 - Branco; Família e tipo: Mini_Balizador_Romi_2841_2842_Nordecor_IFC: 2841 - Branco; ID de tipo: Mini_Balizador_Romi_2841_2842_Nordecor_IFC: 2841 - Branco; Tipo: Mini_Balizador_Romi_2841_2842_Nordecor_IFC: 2841 - Branco
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
